options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: gr_ble
    output_language: python
    title: Bluetooth LE Receiver
  states: {}

blocks:
- name: ble_base_freq
  id: variable
  parameters:
    value: 2402e6
  states: {}
- name: ble_channel
  id: variable
  parameters:
    value: '12'
  states: {}
- name: ble_channel_spacing
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: freq
  id: variable
  parameters:
    value: ble_base_freq+(ble_channel_spacing * ble_channel)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1.0'
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: file0.out
    type: short
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: file1.out
    type: short
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: file.out
    repeat: 'True'
    type: complex
    vlen: '2'
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_short_0_0
  id: blocks_float_to_short
  parameters:
    scale: '1'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
    vlen: '2'
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    type: complex
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
    sensitivity: '1.0'
  states: {}
- name: digital_gfsk_demod_0_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
    sensitivity: '1.0'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '100000'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_float_to_short_0, '0', blocks_file_sink_0, '0']
- [blocks_float_to_short_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_throttle2_0, '0', blocks_vector_to_streams_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_float_to_short_0, '0']
- [blocks_uchar_to_float_0_0, '0', blocks_float_to_short_0_0, '0']
- [blocks_uchar_to_float_0_0, '0', qtgui_time_sink_x_0_0_0, '1']
- [blocks_vector_to_streams_0, '0', digital_gfsk_demod_0, '0']
- [blocks_vector_to_streams_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_vector_to_streams_0, '1', digital_gfsk_demod_0_0, '0']
- [blocks_vector_to_streams_0, '1', qtgui_time_sink_x_0_1, '1']
- [digital_gfsk_demod_0, '0', blocks_uchar_to_float_0, '0']
- [digital_gfsk_demod_0_0, '0', blocks_uchar_to_float_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
