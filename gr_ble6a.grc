options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: gr_ble
    output_language: python
    title: Bluetooth LE Receiver
  states: {}

blocks:
- name: ble_base_freq
  id: variable
  parameters:
    value: 2402e6
  states: {}
- name: ble_channel
  id: variable
  parameters:
    value: '12'
  states: {}
- name: ble_channel_spacing
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: freq
  id: variable
  parameters:
    value: ble_base_freq+(ble_channel_spacing * ble_channel)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: file.out
    type: complex
    vlen: '2'
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: (4*1024*1024)
    type: complex
    vlen: '2'
  states: {}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    type: complex
  states: {}
- name: iio_fmcomms2_sink_0
  id: iio_fmcomms2_sink
  parameters:
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: '2400000000'
    rf_port_select: '''A'''
    samplerate: int(samp_rate)
    tx1_en: 'True'
    tx2_en: 'False'
    type: fc32
    uri: ip:192.168.3.10
  states: {}
- name: iio_fmcomms2_source_0
  id: iio_fmcomms2_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: '2400000000'
    gain1: '''slow_attack'''
    gain2: '''slow_attack'''
    quadrature: 'True'
    rf_port_select: '''A_BALANCED'''
    rfdc: 'True'
    rx1_en: 'True'
    rx2_en: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: ip:192.168.3.10
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', iio_fmcomms2_sink_0, '0']
- [blocks_skiphead_0, '0', blocks_file_sink_0, '0']
- [blocks_streams_to_vector_0, '0', blocks_skiphead_0, '0']
- [iio_fmcomms2_source_0, '0', blocks_streams_to_vector_0, '0']
- [iio_fmcomms2_source_0, '0', qtgui_time_sink_x_0, '0']
- [iio_fmcomms2_source_0, '1', blocks_streams_to_vector_0, '1']
- [iio_fmcomms2_source_0, '1', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
