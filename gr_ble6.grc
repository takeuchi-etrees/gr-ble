options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: gr_ble
    output_language: python
    title: Bluetooth LE Receiver
  states: {}

blocks:
- name: ble_base_freq
  id: variable
  parameters:
    value: 2402e6
  states: {}
- name: ble_channel
  id: variable
  parameters:
    value: '12'
  states: {}
- name: ble_channel_spacing
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: freq
  id: variable
  parameters:
    value: ble_base_freq+(ble_channel_spacing * ble_channel)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: file.out
    type: complex
    vlen: '2'
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: (4*1024*1024)
    type: complex
    vlen: '2'
  states: {}
- name: blocks_skiphead_1
  id: blocks_skiphead
  parameters:
    num_items: (4*1024*1024)
    type: complex
    vlen: '2'
  states: {state: disabled}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    type: complex
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"hackrf=1"'
    bb_gain0: '20'
    freq0: freq
    gain0: '0'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"hackrf=0"'
    bb_gain0: '20'
    freq0: freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: osmosdr_source_0_0
  id: osmosdr_source
  parameters:
    args: '"hackrf=2"'
    bb_gain0: '20'
    freq0: freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: osmosdr_source_1
  id: osmosdr_source
  parameters:
    args: '"hackrf=0"'
    bb_gain0: '20'
    freq0: freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_1_0
  id: osmosdr_source
  parameters:
    args: '"hackrf=2"'
    bb_gain0: '20'
    freq0: freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', osmosdr_sink_0, '0']
- [blocks_skiphead_0, '0', blocks_file_sink_0, '0']
- [blocks_streams_to_vector_0, '0', blocks_skiphead_0, '0']
- [blocks_streams_to_vector_0, '0', blocks_skiphead_1, '0']
- [osmosdr_source_0, '0', qtgui_time_sink_x_0_1, '0']
- [osmosdr_source_0_0, '0', qtgui_time_sink_x_0_1_0, '0']
- [osmosdr_source_1, '0', blocks_streams_to_vector_0, '0']
- [osmosdr_source_1, '0', qtgui_time_sink_x_0, '0']
- [osmosdr_source_1_0, '0', blocks_streams_to_vector_0, '1']
- [osmosdr_source_1_0, '0', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
