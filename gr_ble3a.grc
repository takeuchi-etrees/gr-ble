options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: gr_ble
    output_language: python
    title: Bluetooth LE Receiver
  states: {}

blocks:
- name: ble_base_freq
  id: variable
  parameters:
    value: 2402e6
  states: {}
- name: ble_channel
  id: variable
  parameters:
    value: '12'
  states: {}
- name: ble_channel_spacing
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: freq
  id: variable
  parameters:
    value: ble_base_freq+(ble_channel_spacing * ble_channel)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-40'
  states: {}
- name: analog_simple_squelch_cc_0_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-40'
  states: {}
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters: {}
  states: {}
- name: blocks_correctiq_0_0
  id: blocks_correctiq
  parameters: {}
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: file.out
    type: complex
    vlen: '2'
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: (4*1024*1024)
    type: complex
    vlen: '2'
  states: {}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    type: complex
  states: {}
- name: iio_fmcomms2_source_0
  id: iio_fmcomms2_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: int(freq)
    gain1: '''slow_attack'''
    gain2: '''slow_attack'''
    quadrature: 'True'
    rf_port_select: '''A_BALANCED'''
    rfdc: 'True'
    rx1_en: 'True'
    rx2_en: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: ip:192.168.3.10
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 1e6
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 5e5
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 1e6
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 5e5
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_simple_squelch_cc_0, '0', low_pass_filter_0, '0']
- [analog_simple_squelch_cc_0_0, '0', low_pass_filter_0_0, '0']
- [blocks_correctiq_0, '0', analog_simple_squelch_cc_0, '0']
- [blocks_correctiq_0_0, '0', analog_simple_squelch_cc_0_0, '0']
- [blocks_skiphead_0, '0', blocks_file_sink_1, '0']
- [blocks_streams_to_vector_0, '0', blocks_skiphead_0, '0']
- [iio_fmcomms2_source_0, '0', blocks_correctiq_0, '0']
- [iio_fmcomms2_source_0, '1', blocks_correctiq_0_0, '0']
- [low_pass_filter_0, '0', blocks_streams_to_vector_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0_1, '0']
- [low_pass_filter_0_0, '0', blocks_streams_to_vector_0, '1']
- [low_pass_filter_0_0, '0', qtgui_time_sink_x_0_1, '1']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
